# Keil uVision project f303_foc.uvprojx, settings and files
target f303_foc (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x03E000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f303_foc_fw +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,__FPU_PRESENT,LWRB_DISABLE_ATOMIC,ARM_MATH_CM4,
  c include: ..\libraries\CMSIS;..\libraries\CMSIS\GD\GD32F30x\Include;..\libraries\GD32F30x_standard_peripheral\Include;..\libraries\lwrb;..;..\app;..\bsp;..\driver\drv8323;..\driver\tle5012b;..\foc;..\util;..\libraries\CMSIS-DSP;..\libraries\letter-shell;..\libraries\flashdb\inc;..\libraries\flashdb\port\fal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3e000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../libraries/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../libraries/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../libraries/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group App
    ../app/: main.c gd32f30x_it.c shell_port.c params.c version.h can_proto.c
  group Bsp
    ../bsp/: uart.c can.c pwm_curr.c
  group Driver
    ../driver/drv8323/: drv8323.c
    ../driver/tle5012b/: tle5012b.c
  group FOC
    ../foc/: filter.c foc_core.c foc_ident.c foc_ltu.c fault.c foc_math.c interrupt.c motor_hw.c pid.c pll.c svpwm.c vofa.c
  group Libraries
    ../libraries/lwrb/: lwrb.c lwrb_ex.c
    ../libraries/letter-shell/: shell.c shell_ext.c
  group CMSIS-DSP
    ../libraries/CMSIS-DSP/: arm_cortexM4lf_math.lib
  group FlashDB
    ../bsp/: flash_port.c
    ../libraries/flashdb/port/fal/src/: fal.c fal_flash.c fal_partition.c
    ../libraries/flashdb/src/: fdb.c fdb_kvdb.c fdb_utils.c
